# Keil uVision project H10_8LANE.uvprojx, settings and files
target H10_8LANE (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TO2198A_185_OTP_QSPI_V03 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\USER;.\CORE;.\STDLIB\inc;.\SDCardFile\SDCARD;.\SDCardFile\FATFS;.\SDCardFile;.\BUS;.\S10DRV;.\SYS;.\EXMODULE;.\LWIP\include;.\Power;.\skyLib;.\skySoftware\include;.\S10DRV\skyLib;.\S10DRV\skySoftware\include;.\in_img;.\gamma\gamma
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./USER/: main.c stm32f4xx_it.c bus_rs232_id0.c ssd2828.c in_img.c showtext.c usart1.c driverUsart3.c qspi_lcd.c stm_spi.c driverTCPClient.c driverTCPServer.c driverUDP.c driverUsart1.c User_control.h init_code.h init_code.c driverUsart1.h servo_com.c Public_SoftFunpack.c Bus.c exti.c
    ./in_img/: in_img2.c
    ./EXMODULE/: bus_rs232_id4.c auto_vcom.c
  group CORE
    ./CORE/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group STDLIB
    ./STDLIB/src/: stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_usart.c misc.c stm32f4xx_dac.c stm32f4xx_fsmc.c stm32f4xx_syscfg.c
  group SYS
    ./SYS/: sys.h delay.c systick.c
  group SDCradFile
    ./SDCardFile/FATFS/: diskio.h ff.h ffconf.h integer.h
    ./SDCardFile/SDCARD/: sdcard.h
    ./SDCardFile/: sd_file.h
    ./STDLIB/src/: stm32f4xx_exti.c
  group BUS
    ./BUS/: Bus.h communicationOld.h
  group S10DRV
    ./S10DRV/: gpu.h H10_8LANE.lib key.h OtherVdd.h S10.c S10.h s10power.h sysIO.h versionNumber.h
  group EXMODULE
    ./EXMODULE/: BusCCD.lib FL.lib BL60.h BusCCD.h BusRS232.h cfl.h FL.h scanner.h uartKey.h bus_rs232_id1.c
  group LWIP
    ./LWIP/include/arch/: cc.h cpu.h perf.h sys_arch.h
    ./LWIP/include/lwip/: api.h api_msg.h arch.h autoip.h debug.h def.h dhcp.h dns.h err.h icmp.h igmp.h inet.h inet_chksum.h init.h ip.h ip_addr.h ip_frag.h lwip_sys.h mem.h memp.h memp_std.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h snmp_asn1.h snmp_msg.h snmp_structs.h sockets.h stats.h tcp.h tcp_impl.h tcpip.h timers.h udp.h
    ./LWIP/include/netif/: etharp.h ethernetif.h ppp_oe.h slipif.h
    ./LWIP/include/: lan8720.h lwip_comm.h lwipopts.h lwipsys.h lwipUser.h myTCP.h myUDP.h stm32f4x7_eth.h stm32f4x7_eth_conf.h
  group Sky
    ./skyLib/: deviceCA310.h pcui.h pcui_depend.h
    ./skySoftware/include/: commonCa310.h commonIOInterface.h communication.h myFIFO.h Public_SoftCan.h Public_SoftFunpack.h Public_SoftLogDebug.h Public_SoftStringCmd.h
  group gamma
    ./gamma/gamma/: gamma.lib
target H (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: as above
  output: gamma +hex (library)
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
